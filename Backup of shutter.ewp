# IAR project Backup of shutter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1549 NXP LPC1549
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M3
  ICCARM.PreInclude: src\main.h
  ICCARM.CCIncludePath2: software\CMSIS\CMSIS\Include; software\lpc_core\lpc_chip\chip_15xx\config_15xx; software\lpc_core\lpc_chip\chip_common; software\lpc_core\lpc_chip; src; software\lpc_core\lpc_chip\chip_15xx
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: shutter.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: AAEC018.280.003.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CORE_M3
  ICCARM.CCOptLevel: 3
  group Docs
    Src/: Readme.txt
  group Headers
    Src/: board.h i2c.h main.h memory.h one_wire.h servo_control.h shutter.h spi.h timers.h
  group Lib
    software/lpc_core/lpc_chip/chip_15xx/iar_output/chip_15xx_lib/Exe/: chip_15xx_lib.a
  group Src
    Src/: board.c i2c.c memory.c one_wire.c servo_control.c shutter.c spi.c timers.c
    ./: main.c
  group Startup
    startup_code/: iar_startup_lpc15xx.s
