# IAR project lib_lpc_chip_15xx.ewp, settings and files
configuration chip_15xx_lib (ARM, debug)
  General.OGChipSelectEditMenu: LPC1549 NXP LPC1549
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; config_15xx; ..\chip_common; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_lpc_chip_110x.out
  group csp
    ./: acmp_15xx.c adc_15xx.c chip_15xx.c clock_15xx.c crc_15xx.c dac_15xx.c dma_15xx.c gpio_15xx.c i2c_common_15xx.c i2cm_15xx.c i2cs_15xx.c iocon_15xx.c pinint_15xx.c pmu_15xx.c ritimer_15xx.c rtc_15xx.c sct_15xx.c sct_pwm_15xx.c sctipu_15xx.c spi_15xx.c stopwatch_15xx.c swm_15xx.c sysctl_15xx.c sysinit_15xx.c uart_15xx.c wwdt_15xx.c
    ../chip_common/: eeprom.c iap.c ring_buffer.c
